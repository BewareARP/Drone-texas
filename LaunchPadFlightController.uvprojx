# Keil uVision project LaunchPadFlightController.uvprojx, settings and files
target TM4C123GH6PM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LaunchPadFlightController
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM UART_BUFFERED UART_BUFFERED1 UART_DEBUG=1 USE_MAG=0 USE_BARO=0 USE_SONAR=1 USE_LIDAR_LITE=0 STEP_ACRO_SELF_LEVEL=0 STEP_ALTITUDE_HOLD=0 STEP_HEADING_HOLD=0
  c include: .\lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group src
    ./src/: main.c startup_rvmdk.S RX.c UART.c Time.c PPM.c MPU6500.c PID.c Sonar.c I2C.c EEPROM.c Bluetooth.c uartstdio1.c Buzzer.c IMU.c HMC5883L.c BMP180.c AltitudeHold.c HeadingHold.c StepResponse.c AK8963.c Magnetomer.c LidarLiteV3.c LowPassFilter.c
    ./lib/utils/: uartstdio.c ustdlib.c uartstdio2.c
    ./lib/driverlib/rvmdk/: driverlib.lib
